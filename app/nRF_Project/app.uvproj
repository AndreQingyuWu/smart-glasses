# Keil uVision project app.uvproj, settings and files
target App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: app +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF_LOG_USES_RTT=1 BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF_LOG_USES_UART=1 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52
  c misc: --c99
  c include: ..\nRF_APP;..\nRF_Ble\inc;..\nRF_Bsp\inc;..\nRF_Device\inc;..\nRF_Driver\inc;..\nRF_Library\inc;..\nRF_APP\inc;..\..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.7.0\CMSIS\Include
  asm define: BLE_DFU_APP_SUPPORT BLE_STACK_SUPPORT_REQD S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET NRF_LOG_USES_UART=1 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20001fe8 size 0xe018
  group nRF_App
    ./: arm_startup_nrf52.s
    ../nRF_APP/src/: glass_app.c glass_calc.c main.c sys_debug.c glass_ble.c
    ../nRF_APP/src/motor/: motor.c
    ../nRF_APP/src/accel/: bmi160.c
    ../nRF_APP/src/touch/: zw101g.c
    ../nRF_APP/src/tof/: vl53l1.c vl53l1_api.c vl53l1_api_calibration.c vl53l1_api_core.c vl53l1_api_debug.c vl53l1_api_preset_modes.c vl53l1_api_strings.c vl53l1_core.c vl53l1_core_support.c vl53l1_error_strings.c vl53l1_register_funcs.c vl53l1_silicon_core.c vl53l1_wait.c
  group nRF_Bsp
    ../nRF_Bsp/src/: bsp.c bsp_btn_ble.c
  group nRF_Ble
    ../nRF_Ble/src/: ble_advdata.c ble_advertising.c ble_bas.c ble_conn_params.c ble_dfu.c ble_dis.c ble_hrs.c ble_srv_common.c device_manager_peripheral.c ble_nus.c
  group nRF_Device
    ../nRF_Device/src/: softdevice_handler.c system_nrf52.c
  group nRF_Driver
    ../nRF_Driver/src/: app_uart_fifo.c nrf_delay.c nrf_drv_common.c nrf_drv_gpiote.c nrf_drv_uart.c pstorage.c nrf_drv_twi.c
  group nRF_Library
    ../nRF_Library/src/: app_button.c app_error.c app_error_weak.c app_fifo.c app_timer.c app_trace.c app_util_platform.c bootloader_util.c dfu_app_handler.c fstorage.c nrf_assert.c nrf_log.c retarget.c RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c sensorsim.c app_twi.c
