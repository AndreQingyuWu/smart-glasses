# Keil uVision project bootv1.0.uvproj, settings and files
target bootv1.0 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: bootv1.0 +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 BSP_DEFINES_ONLY NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\nRF_App;..\nRF_Ble\inc;..\nRF_Bsp\inc;..\nRF_Device\inc;..\nRF_Driver\inc;..\nRF_Library\inc;..\nRF_SoftDevice\inc
  asm define: as above
  memory RVCT4: ROM 0x7a000 size 0x4000
  memory RVCT9: RAM 0x20002c00 size 0xd380
  memory RVCT10: RAM 0x2000ff80 size 0x80
  group nRF_App
    ../nRF_App/src/: dfu_ble_svc.c main.c
  group nRF_Ble
    ../nRF_Ble/src/: ble_advdata.c ble_conn_params.c ble_dfu.c ble_srv_common.c
  group nRF_Device
    ./: arm_startup_nrf52.s
    ../nRF_Device/src/: system_nrf52.c
  group nRF_Driver
    ../nRF_Driver/src/: nrf_delay.c nrf_drv_common.c pstorage_raw.c
  group nRF_Library
    ../nRF_Library/src/: app_error.c app_error_weak.c app_scheduler.c app_timer.c app_timer_appsh.c app_util_platform.c bootloader.c bootloader_settings.c bootloader_util.c crc16.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c hci_mem_pool.c nrf_assert.c
  group nRF_SoftDevice
    ../nRF_SoftDevice/src/: softdevice_handler.c softdevice_handler_appsh.c
